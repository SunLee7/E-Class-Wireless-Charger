# Keil uVision project Class E.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Class E +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Class E
  group Source Group 1
    ./: STARTUP.A51 main.c bmp.h oled.c oled.h oledfont.h adc.c adc.h debug.c debug.h myprintf.c myprintf.h
